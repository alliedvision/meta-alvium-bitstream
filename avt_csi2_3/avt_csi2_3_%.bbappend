KERNEL_MODULE_AUTOLOAD:remove = "avt-csi2-3"
